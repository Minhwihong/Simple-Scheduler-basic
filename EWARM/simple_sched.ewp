# IAR project simple_sched.ewp, settings and files
configuration Simple_Sched (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446VE ST STM32F446VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Control\MyTasks; ..\Control\Components; ..\Control\MyCtl; ..\Model; ..\ThirdParty\TinyPrintf; ..\kernel
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\kernel
  OBJCOPY.OOCOutputFile: Simple_Sched.hex
  ILINK.IlinkOutputFile: Simple_Sched.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/User/Control/Components
    ../Control/Components/: IBMPlexMono_Regular.c IBMPlexMono_Regular.h Lato_Regular.c Lato_Regular.h max31865.c max31865.h ssd1322.c ssd1322.h
  group Application/User/Control/MyCtl
    ../Control/MyCtl/: comm.c comm.h myQueue.c myQueue.h
  group Application/User/Control/MyTasks
    ../Control/MyTasks/: myTasks.c myTasks.h task_basic.c task_board.c task_comm.c task_fluid.c task_heat.c task_movement.c task_ui.c taskDef.h
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/Kernel
    ../kernel/: kernel.c kernel.h skernel.s
  group Application/User/Model
    ../Model/: ModelConfig.h
  group Application/User/ThirdParty/TinyPrintf
    ../ThirdParty/TinyPrintf/: printf.c printf.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_adc.c
